# IAR project mmc_inand_fat.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: am3359 TexasInstruments am3359
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: am335x; BEAGLEBONExx
  ICCARM.CCDiagSuppress: Pa050,Pe1750
  ICCARM.CCIncludePath2: ..\..\..\lib\peri_drivers\include\; ..\..\..\lib\peri_drivers\include\hw\; ..\..\..\lib\mmcsdlib\include\; ..\..\..\lib\platform\include\; ..\..\..\lib\cpu\include\; ..\..\..\lib\fatfs\src\; ..\..\..\lib\fatfs\port\; ..\..\..\lib\usblib\include\; ..\..\..\lib\cpu\include\armv7a\; ..\..\..\lib\utils\include\; ..\..\..\lib\font\; ..\..\..\lib\gui\; ..\..\..\src\mmc_inand_fat\config\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\..\..\lib\peri_drivers\include\hw\
  OBJCOPY.OOCOutputFile: mmc_inand_fat.bin
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkIcfFile: ..\..\tool\ewarm\am335x.icf
  ILINK.IlinkProgramEntryLabel: Entry
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; am335x
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: mmc_inand_fat.srec
  group lib/cpu
    ../../../lib/cpu/armv7a/: cache.c mmu.c
    ../../../lib/cpu/: clock.c interrupt.c startup.c
    ../../../lib/cpu/armv7a/ewarm/: cp15.S cpu.S init.S
    ../../../lib/cpu/ewarm/: exceptionhandler.S
  group lib/fatfs/port
    ../../../lib/fatfs/port/: diskio.c diskio.h
  group lib/fatfs/src
    ../../../lib/fatfs/src/: ff.c ff.h ff_ext.c ff_ext.h integer.h
  group lib/gui
    ../../../lib/gui/: ascii_16.c ascii_20.c font.c GUI_draw.c GUI_SIF_Prop.c GUICharP.c GUIType.h lib_gui.h utf8.c utf8.h
  group lib/linker
    ../../tool/ewarm/: am335x.icf
  group lib/mmcsdlib
    ../../../lib/mmcsdlib/: mmcsd_proto.c mmcsd_proto_hooks.c mmcsdhost.c
  group lib/per_drivers
    ../../../lib/peri_drivers/: cppi41dma.c cpsw.c dcan.c dmtimer.c ecap.c edma.c ehrpwm.c elm.c gpio_v2.c gpmc.c hs_mmcsd.c hsi2c.c mailbox.c mcasp.c mcspi.c mdio.c phy.c raster.c rtc.c tsc_adc.c uart_irda_cir.c usb.c usbphyGS70.c watchdog.c
  group lib/platform
    ../../../lib/platform/: am335x_clock_data.c am335x_module_data.c pf_cpsw.c pf_dcan.c pf_dmtimer.c pf_ecap.c pf_edma.c pf_eeprom.c pf_gpio.c pf_hs_mmcsd.c pf_hsi2c.c pf_int.c pf_key_touchpad.c pf_lcd.c pf_module.c pf_mux.h pf_norflash.c pf_pwmss.c pf_qep.c pf_rtc.c pf_rx8025.c pf_spi.c pf_sysperf.c pf_timertick.c pf_tsc.c pf_uart.c pf_uartConsole.c pf_usb.c pf_usbmsc.c pf_watchdog.c
  group lib/usblib
    ../../../lib/usblib/: usbbuffer.c usbdata.c usbdesc.c usbkeyboardmap.c usbringbuf.c usbtick.c
  group lib/usblib/device
    ../../../lib/usblib/device/: usbdbulk.c usbdcdc.c usbdcdesc.c usbdcomp.c usbdconfig.c usbdenum.c usbdhandler.c usbdhid.c usbdhidmouse.c usbdmsc.c
  group lib/usblib/host
    ../../../lib/usblib/host/: usbhhid.c usbhhidkeyboard.c usbhhidmouse.c usbhmsc.c usbhostenum.c usbhscsi.c
  group lib/utils
    ../../../lib/utils/: algorithm.c cmdline.c mem.c misc.c perf.c uartStdio.c
  group src
    ../../../src/mmc_inand_fat/: mmc_inand_fat.c platform.c
  group src/config
    ../../../src/mmc_inand_fat/config/: ffconf.h
  group src/include
    ../../../src/include/: cpld.h
